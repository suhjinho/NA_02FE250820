# Keil uVision project KEIL_proj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KEIL_proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: .\Source\Core\CMSIS\Include;.\Source\Core\Device\ABOV\A31G21x\Include;.\Source\Drivers\Include;.\
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Device
    ./Source/Core/Device/ABOV/A31G21x/Source/: system_A31G21x.c
  group Main
    ./Source/Main/: Init.c main.c Irq.c SystemClock.c xprintf.c hal.c key.c sound.c app_sensing.c app_ctl.c app_normal.c app_setting.c app_data.c queue.c sensor.c io.c modbus.c flash.c fnd.c
  group Startup
    ./Source/Core/Device/ABOV/A31G21x/Source/ARM/: startup_A31G21x.s
  group Drivers
    ./Source/Drivers/Source/: A31G21x_hal_adc.c A31G21x_hal_crc.c A31G21x_hal_debug_frmwrk.c A31G21x_hal_i2c.c A31G21x_hal_pcu.c A31G21x_hal_pwr.c A31G21x_hal_scu.c A31G21x_hal_timer1n.c A31G21x_hal_timer2n.c A31G21x_hal_timer30.c A31G21x_hal_uartn.c A31G21x_hal_usart1n.c A31G21x_hal_wdt.c A31G21x_hal_wt.c
software components: CMSIS:CORE 5.1.1
